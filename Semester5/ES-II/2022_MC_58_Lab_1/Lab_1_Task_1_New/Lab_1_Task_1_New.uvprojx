# Keil uVision project Lab_1_Task_1_New.uvprojx, settings and files
target TM4C123GH6PM (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab_1_Task_1_New
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Lab_1_Task_1_New.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
