# Keil uVision project Final_Lab_Evaluation.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\v5)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Final_Lab_Evaluation
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Exercize_2.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
